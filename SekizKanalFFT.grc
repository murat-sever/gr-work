<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SekizKanalFFT</value></param>
<param><key>author</key><value>Murat Sever</value></param>
<param><key>category</key><value>Aselsan</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>8 Kanal FFT</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>AlmacFFTKanal</key>
<param><key>id</key><value>AlmacFFTKanal_0</value></param>
<param><key>indeks</key><value>0</value></param>
</block>
<block>
<key>AlmacFFTKanal</key>
<param><key>id</key><value>AlmacFFTKanal_1</value></param>
<param><key>indeks</key><value>1</value></param>
</block>
<block>
<key>AlmacFFTKanal</key>
<param><key>id</key><value>AlmacFFTKanal_2</value></param>
<param><key>indeks</key><value>2</value></param>
</block>
<block>
<key>AlmacFFTKanal</key>
<param><key>id</key><value>AlmacFFTKanal_3</value></param>
<param><key>indeks</key><value>3</value></param>
</block>
<block>
<key>AlmacFFTKanal</key>
<param><key>id</key><value>AlmacFFTKanal_4</value></param>
<param><key>indeks</key><value>4</value></param>
</block>
<block>
<key>AlmacFFTKanal</key>
<param><key>id</key><value>AlmacFFTKanal_5</value></param>
<param><key>indeks</key><value>5</value></param>
</block>
<block>
<key>AlmacFFTKanal</key>
<param><key>id</key><value>AlmacFFTKanal_6</value></param>
<param><key>indeks</key><value>6</value></param>
</block>
<block>
<key>AlmacFFTKanal</key>
<param><key>id</key><value>AlmacFFTKanal_7</value></param>
<param><key>indeks</key><value>7</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_5</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_7</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>int</value></param>
</block>
<connection><source_block_id>AlmacFFTKanal_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AlmacFFTKanal_1</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AlmacFFTKanal_2</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AlmacFFTKanal_3</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AlmacFFTKanal_4</source_block_id><sink_block_id>pad_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AlmacFFTKanal_5</source_block_id><sink_block_id>pad_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AlmacFFTKanal_6</source_block_id><sink_block_id>pad_sink_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AlmacFFTKanal_7</source_block_id><sink_block_id>pad_sink_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>AlmacFFTKanal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>AlmacFFTKanal_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>AlmacFFTKanal_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>AlmacFFTKanal_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>AlmacFFTKanal_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>AlmacFFTKanal_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>AlmacFFTKanal_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>AlmacFFTKanal_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
