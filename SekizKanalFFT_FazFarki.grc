<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>SekizKanalFFT</key>
<param><key>id</key><value>SekizKanalFFT_0</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/fft_yon_sim_25Mcenter_30azi_45el.bin</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>/tmp/faz0.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0</value></param>
<param><key>file</key><value>/tmp/faz1.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2</value></param>
<param><key>file</key><value>/tmp/genlik0.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0</value></param>
<param><key>file</key><value>/tmp/fazfarki_0_1.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_0</value></param>
<param><key>file</key><value>/tmp/fazfarki_0_2.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_0_0</value></param>
<param><key>file</key><value>/tmp/fazfarki_0_3.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_0_0_0</value></param>
<param><key>file</key><value>/tmp/fazfarki_0_4.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_0_0_0_0</value></param>
<param><key>file</key><value>/tmp/fazfarki_0_5.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_0_0_0_0_0</value></param>
<param><key>file</key><value>/tmp/fazfarki_0_6.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_0_0_0_0_1</value></param>
<param><key>file</key><value>/tmp/fazfarki_0_7.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_1</value></param>
<param><key>file</key><value>/tmp/genlik1.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3</value></param>
<param><key>file</key><value>/tmp/fft0.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_0</value></param>
<param><key>file</key><value>/tmp/fft1.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/tmp/fft_yon_sim_25Mcenter_30azi_45el.bin</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>96</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>38</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>96</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>38</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>96</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>38</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>96</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>38</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0_0_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>96</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>38</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0_0_0_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>96</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>38</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0_0_0_0_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>96</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>38</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0_0_0_0_1</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>96</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>38</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_0_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_0_0_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_0_0_0_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_0_0_0_0_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_0_0_0_0_1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ipaddr</key><value>18.2.26.45</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
<param><key>psize</key><value>8*96*8</value></param>
<param><key>port</key><value>20004</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>96</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>150</value></param>
<param><key>ymin</key><value>20</value></param>
</block>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_file_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_file_sink_3_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0_0_0_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0_0_0_0_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SekizKanalFFT_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0_0_0_0_1</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0_0</source_block_id><sink_block_id>blocks_file_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_file_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_1</source_block_id><sink_block_id>blocks_file_sink_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>SekizKanalFFT_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_complex_to_arg_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_file_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_0</source_block_id><sink_block_id>blocks_file_sink_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_0_0</source_block_id><sink_block_id>blocks_file_sink_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_2_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_2_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_2_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_file_sink_2_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>SekizKanalFFT_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
